# Keil uVision project My_STM32.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: My_STM32 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\TIME;..\HARDWARE\LCD;..\HARDWARE\IMAGE2LCD;..\HARDWARE\USART3;..\HARDWARE\WIFI;..\HARDWARE\OLED
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c
  group STSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../HARDWARE/USART3/: usart3.c
  group HARDWARD
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIME/: time.c
    ../HARDWARE/LCD/: lcd.c
  group IMAGE
    ../HARDWARE/IMAGE2LCD/: image2lcd.c image1.c
  group WIFI
    ../HARDWARE/WIFI/: common.c wifista.c
  group OLED
    ../HARDWARE/OLED/: OLED_I2C.c codetab.c
