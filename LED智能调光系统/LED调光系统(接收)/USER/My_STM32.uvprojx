# Keil uVision project My_STM32.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: My_STM32 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\TIME;..\OS;..\MALLOC;..\HARDWARE\24L01;..\HARDWARE\OLED;..\HARDWARE\KEY;..\HARDWARE\ADC;..\HARDWARE\LSENS;..\HARDWARE\PID;..\HARDWARE\Data;..\HARDWARE\STMFLASH;..\HARDWARE\WIFI
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_adc.c stm32f10x_flash.c
  group STSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARD
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIME/: time.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/LSENS/: lsens.c
    ../HARDWARE/PID/: pid.c motor.c
    ../HARDWARE/Data/: DataScope_DP.C
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/WIFI/: esp8266.c
  group OS
    ../OS/: core.asm os.c
  group MALLOC
    ../MALLOC/: malloc.c
  group OLED
    ../HARDWARE/OLED/: codetab.c OLED_I2C.c
  group 24L01
    ../HARDWARE/24L01/: 24l01.c
